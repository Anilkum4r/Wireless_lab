options:
  parameters:
    generate_options: qt_gui
    id: hardware
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: Noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: QPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nfilts_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: phase_bw
  id: variable_qtgui_range
  parameters:
    label: 'Phase: Bandwidth'
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW'
    start: '0.0'
    step: '0.01'
    stop: '0.2'
    value: 6.28/100.0
    widget: slider
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_rect_0
    modulus: '4'
    step_size: '.0001'
    type: cma
  states: {}
- name: variable_constellation_rect_0
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '500'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_modulator_1
  id: digital_constellation_modulator
  parameters:
    constellation: QPSK
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: arity
    w: phase_bw
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '15'
    sps: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: timing_loop_bw
    max_dev: '1.5'
    osps: '2'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_1
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '10000'
    type: '0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      from gnuradio import grc
      import inspect


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AMC selector based on SNR',   # will show up in GRC
                  in_sig=[np.complex64,np.complex64],
                  out_sig=[np.complex64]
              )
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.last_snr = 0
              self.is_mod_changed=False;
              self.selector=0
              self.last_selector=0
              self.bpsk_max=12
              self.qpsk_max=9
              self.tag_added=True
              self.index=0;
          
          def handle_msg(self, msg):
              self.last_snr=pmt.to_double(msg)
              if self.last_snr >=0 and self.last_snr < 40:
                  self.selector=0
              elif self.last_snr >=40:
                  self.selector=1
             
              if self.selector!=self.last_selector:
                  self.last_selector=self.selector
                 
                  self.tag_added=False
            

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if self.tag_added!= True:
                  self.add_item_tag(0, self.nitems_written(0), pmt.intern('mod'), pmt.from_long(self.selector))
                  self.tag_added=True
              output_items[0][:] = input_items[self.selector]
              return len(output_items[0])
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from gnuradio import grc

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='datatypeconversion',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.snr=0
              #print(222)
          def handle_msg(self,msg):
              self.snr=pmt.to_float(msg)
              #print(22)
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print(2)
              output_items[0][:] = abs(self.snr) 
              return len(output_items[0])
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '2000'
    freq0: 100e6
    gain0: '1000'
    if_gain0: '2000'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    bb_gain0: '2000'
    freq0: 100e6
    gain0: '1000'
    gain_mode0: 'False'
    if_gain0: '2000'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Received constellation"'
    size: '1024'
    type: complex
    xmax: '15'
    xmin: '-15'
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_number_sink_0_0_1
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 'SNR '
    max: '30'
    min: '0'
    name: reciver snr
    type: float
    unit1: dB
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: QPSK
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: BPSK
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: feedback
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: QPSK
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: BPSK
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: feedback
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_1, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0_1, '0']
- [digital_constellation_modulator_1, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_probe_mpsk_snr_est_c_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [digital_linear_equalizer_0, '0', digital_costas_loop_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_linear_equalizer_0, '0']
- [digital_probe_mpsk_snr_est_c_1, snr, blocks_message_debug_0, print]
- [digital_probe_mpsk_snr_est_c_1, snr, epy_block_1_0, snr]
- [digital_probe_mpsk_snr_est_c_1, snr, virtual_sink_2, '0']
- [epy_block_0_0, '0', osmosdr_sink_0, '0']
- [epy_block_1_0, '0', qtgui_number_sink_0_0_1, '0']
- [osmosdr_source_0_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', epy_block_0_0, '1']
- [virtual_source_0_0, '0', epy_block_0_0, '0']
- [virtual_source_2, '0', epy_block_0_0, snr]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
